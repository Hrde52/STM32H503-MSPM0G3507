# IAR project gpio_toggle_output_LP_MSPM0G3507_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSPM0G3507 TexasInstruments MSPM0G3507
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __MSPM0G3507__
  ICCARM.IExtraOptions: --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; E:\HTC\REPEATER\0925\source\third_party\CMSIS\Core\Include; E:\HTC\REPEATER\0925\source; E:\HTC\REPEATER\ti\mspm0_sdk_2_01_00_03\source\third_party\CMSIS\Core\Include; E:\HTC\REPEATER\ti\mspm0_sdk_2_01_00_03\source
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: gpio_toggle_output_LP_MSPM0G3507_nortos_iar.srec
  ILINK.IlinkOutputFile: gpio_toggle_output_LP_MSPM0G3507_nortos_iar.out
  ILINK.IlinkAdditionalLibs: E:\HTC\REPEATER\0925\source\ti\driverlib\lib\iar\m0p\mspm0g1x0x_g3x0x\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group gpio_toggle_output
    ./: mspm0g3507.icf README.html README.md typdef.h zcom485.c zscl1_process.c zscl1_process.h zscl1_variate.c zscl1_variate.h zscl2_process.c zscl2_process.h zscl2_variate.c zscl2_variate.h zscl_delay_main.c zscl_logic.c zscl_logic.h
  group gpio_toggle_output/iar
    iar/: startup_mspm0g350x_iar.c
  group SysConfig Generated Files
    ./: ti_msp_dl_config.c ti_msp_dl_config.h
